# Keil uVision project WS2812.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8F2K64S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x07FF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: WS2812 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c UART1.c led_task.c
    ./startup/: STARTUP.A51
